# Keil uVision project 智能小车.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: 智能小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 智能小车.c EEPROM.c eeprom.h
